# Repository micromouseuci/UCI-Micromouse

File README.md:

# UCI Micromouse

This is the official GitHub of Micromouse @ UCI. This repository is here to allow you to build your own mouse for competition. 

#### Club Resources
 * [__Official Club Website__](https://micromouseuci.github.io/) - Get updates on club meetings and club information
 * [__Micromouse @UCI Team Drive__](https://drive.google.com/drive/folders/1fHwfOaCsH3-F_LZoAcfiGgn9cWiebsPj) - Reference Sheets, Lecture Slides, and more informative documents
 * [__YouTube Playlist__](https://www.youtube.com/playlist?list=PLTnmBeaLzeHIIcfAZqYvjoWuxOcVnpV9Z) - Official Micromouse@UCI playlist that includes helpful video references on a wide range of subjects, ranging from soldering and safety to PID control and ChibiOS
 * [__Facebook__](https://www.facebook.com/groups/153805515376853) - Club Facebook (only UCI students can join)
 
 #### Navigation
 To help you navigate through this repository, here is an overview of each section.
 1. <strong>Schematic Reference</strong> - Shows the schematic of the PCB. Use this to refer back to the PCB as you are soldering and testing components on the PCB. 
 2. <strong>Setting Up Arduino and Teensy</strong> - How to download and set up the Arduino software and Teensy drivers
 3. <strong>Soldering Components</strong> - simple instructions on how to solder each component onto the PCB.
 4. <strong>Testing</strong> - testing components using breadboards
 5. <strong>Software</strong> - programming instructions and suggestions

 <details>
 <summary><strong>Schematic Reference</strong></summary>
 <p>This is the schematic for Micromouse at UCI's PCB. The parts are listed below the image, with the labels in parentheses. Below the labels are further explanations of each circuit so that you can get an understanding of how each circuit works and why we included them in the PCB</p>

* [__SN754410NE__](https://www.digikey.com/product-detail/en/texas-instruments/SN754410NE/296-9911-5-ND/380180) _(U2)_ - Motor driver, used to control the speed and direction of the two motors.
* [__Teensy 3.2__](https://www.pjrc.com/teensy/teensy31.html) _(U1)_- Processor, will run code.
* [__IR Emitters__]() _(D0-D3)_ - Send an IR signal, which will bounce off walls, allowing for the reciever to read. Each is connected to a digital pin on the Teensy, allowing them to individual turn on and off.
* [__IR Reciever__]() _(Q0-Q3)_ - Reads how strong the IR signal is, depending on the value it reads it is able to detect if there is a wall, and how may cells away it is.
* [__Pololu 3081__](https://www.pololu.com/product/3081) _(U5, U4)_ - Motor encoders, used to keep track of wheel rotations.
* [__LM1085 (3A)__](http://www.ti.com/product/LM1085) _(U3)_ - Voltage regulator, a LDO regulator that gives a 5V source from the LiPo. 3A version.
* [__Switch__](http://www.google.com/search?q=mechanical+keyboard+switch) _(SW1)_ - Any mechanical keyboard switch
* [__Buzzer__](https://www.amazon.com/BETAFPV-Terminals-Electronic-Continuous-12X9-5mm/dp/B073RH8TQK) _(BZ1)_ - ~5mm buzzer pin spacing, the small ones in the link fit.
* [__LEDs__](http://www.google.com/search?q=3528+smd+led) _(D4, D5)_ - Any 3528 sized led rated for at least 3.3v
* [__Voltage Regulator (Linear)__](https://www.digikey.com/product-detail/en/stmicroelectronics/LD1085V50/497-3436-5-ND/669220) - Used to step voltage down
* __1.8KΩ__ _(R1, R2, R3, R4)_ - Current limiting resistors for Receivers.
* __35Ω__ _(R5, R6, R7, R8)_ - Current limiting resistor for Recievers.
* __47kΩ__ _(R13, R14, R15, R16)_ - Pull Up resistor for switch. Value based on the LED bought. [Calculate](http://www.ohmslawcalculator.com/led-resistor-calculator)
* __1kΩ__ _(R9, R10, R11, R12)_ - Resistors for MOSFET gate

 <details>
 <summary><strong>Emitter/Receiver Pair Circuit</strong></summary>
 </details>
 
 <details>
 <summary><strong>Power Supply Circuit</strong></summary>
 </details>

 <details>
 <summary><strong>Motor Control Circuit</strong></summary>
 </details>

 <details>
 <summary><strong>Indicator Circuit</strong></summary>
 </details>

 </details>
 
 <details>
 <summary><strong>Setting Up Arduino and Teensy</strong></summary>
 
 <p>In order to run your scripts on your computer, you will need to install Arduino.</p>
 
 * [__Download Arduino Software__]( https://www.arduino.cc/en/software) - Download the correct version based on the system you are using. Avoid downloading the Zip file if you are using Windows.
 * [__Download Teensyduino__](https://www.pjrc.com/teensy/td_download.html) - Download the Teensyduino software for your system. Make sure that you select the Teensyduino, as there are many links on this website that point to the Arduino website that you had downloaded the Arduino software from.

 </details>

<details>
 <summary><strong>Soldering Components</strong></summary>
 
 <p>The components must be soldered in order to maintain a solid electrical connection between two circuit elements. For ease, it's recommended that you follow the order listed below of components to solder. This will help prevent a mess or short circuits.</p>

   <ul><details>
 <summary><strong>Capacitors</strong></summary>
  </details></ul>

 <ul><details><summary><strong>IR Emitters and Receivers</strong></summary>
  <br> <li>On the schematic, the IR Emitters are labeled as D0, D1, D2, and D3. Find the corresponding labels on the PCB. They should be at the front of the board</li>
  <li>Place the shorter end of the emitter in the positive throughole of the corresponding pad and the longer end through the negative side. For reference, the D0 pad is shown below.</li>
  
  <li>After inserting the emitter all the way, bend the emitter's leads so that the emitter lines up parallel to the PCB AND it is centered on the emitter sillhouette on the PCB. You can now solder the emitter. </li>
  <li>Repeat the same process for the IR Receivers. The receivers are located right next to the emitters, and are labelled as Q0, Q1, Q2, and Q3. For the receivers, the short end is also the positive end</li>
  <li>When you're soldering the components, make sure that the LEDs line up with the sillhouettes as much as possible. In other words, the length of the leads above the PCB should be as short as possible. This will ensure that one receiver from one set will not have interference from an emitter of another set. </li>
  </details></ul>
 
 <ul><details><summary><strong>Motors and Encoders</strong></summary>
 
 <ul>The image above shows all the components you will need to install your motor to your PCB.</ul>
 <ul>The first step is to attach the JST connector (the wires) to the encoder. The encoder is the mini black circuit board with a connecter pin for the JST.</ul>
 
 <ul>To solder the encoder to the motor, use the image below as a reference. Make sure the encoder is perfectly parallel to the back end of the motor; if the encoder is crooked, it may cause some additional problems. Cover those holes on the encoder with solder while also making sure that the motor pins are touching the solder. This way, the motor pins are electrically connected to the encoders through solder. Give a slight tug to the encoder to make sure that it is firmly attached to the motor and is not loose. If it is loose, re-solder the encoder until it fits perfectly.</ul>
 
 <ul>Finally, attach the magnet to the motor by inserting it through the mini shaft. The final product should look like the image below.  </ul>
 
 <ul> When it comes time to install the motor onto the PCB, you will need to make sure to have your motor offsets ready. First, place the motor offset onto the PCB, lining up with the motor holes. </ul>
 </details></ul>
 
 <ul><details>
 <summary><strong>MOSFETs and Resistors</strong></summary>
  
 <p>To solder the resistor, first make sure that the right resistor value is selected. Choosing the incorrect resistor value may result in irregular functionality; to determine which resistor must be used, first look at the KiCAD schematic of the mouse. Each resistor on the PCB is labeled as "R#" (i.e. R7). Find the corresponding resistor value on the schematic, and that will be the resistor value needed at that point (i.e. R7 is labeled as 35 ohms, so you will need a 35 ohm resistor at R7). To solder, simply bend the resistor and insert them into the holes specified (as shown above). The ceramic part of the resistor should be lined up with the rectangular engraving on the PCB and should touch the PCB. Solder the ends of the resistor at the bottom of the PCB, and then cut off the ends. The final product should look like this:</p>

 <p>The MOSFETs will be soldered on in a similar manner. All the MOSFET pads will be labeled as "T#" (i.e. T2) on the board. Place the MOSFET on the pad, with the flat face lined up with the straight edge of the MOSFET sillhouette. This will ensure the correct orientation of the transistor. Push the MOSFET in as much as you can. Solder the leads from the bottom of the board and cut off the ends. </p>
 
  </details></ul>

 <ul><details>
 <summary><strong>Voltage Regulator</strong></summary>
 
 <p>YouTube Video (https://youtu.be/L_DIpklxXcI).</p>
  </details></ul> 

   <ul><details>
 <summary><strong>Switches and Buzzer</strong></summary>
  </details></ul>
  
   <ul><details>
 <summary><strong>Header Pins & Dip Socket</strong></summary>
 <ul>The header pins and dip socket are used for easy replacement of the Teensy and motor driver respectively in the event that they burn out. </ul>
 <ul>For the Teensy, you will need two 1x14 headers and one 1x5 header. Solder them on individually in the location shown below</ul>

  </details></ul>
  <ul><details>
  <summary><strong>Header Pins for Teensy</strong></summary>
 <p>To add connections to the Teensy, male header pins must be installed onto the Teensy. Open the pack of male header pins, and break off two pieces of 14-unit pins (since the Teensy has 14 pins lengthwise) and one 5-unit piece (widthwise). When soldering the pins on, ensure that the black caps go UNDER the Teensy board, and not on top (image shown below). Once you solder them, cut off the top leads. You will also need to insert 1 pin into the final hole in the Teensy. You should now be able to place the Teensy on the header pins.  </p>

  </details></ul>
 
</details>
 
<details>
<summary><strong>Testing</strong></summary>
 
 <ul><details><summary><strong>IR Sensors</strong></summary>

</details></ul>

<ul><details>
<summary><strong>Motors</strong></summary>

</details></ul>

</details>
 
<details>
<summary><strong>Software</strong></summary>

#### Interrupts

* Interrupts are needed to keep track of the wheels revolution. When the wheels position changes, the motor encoder will send a signal to the Teensy. A total of 12 signals will be sent per 1 revolution. Interrupts allow it so the Teensy can update values as soon as the encoder sends the signal (asynchronously). If the encoders were updated in the main loop theres a good chance for some signals to be missed, causing the revolution count to be inaccurate.   

* To add an interrupt run the [attatchInterrupt](https://www.arduino.cc/reference/en/language/functions/external-interrupts/attachinterrupt/) function in setup. Syntax is **attatchInterrupt(pin, func, mode)**. The second parameter specifies the function that gets executed when the interrupt is triggered. In our case we want to put in a function that will add to the count of an encoder variable. The third parameter specifies what will trigger the interrupt. For example "CHANGE" will make the interrupt trigger whenever the pin changes value, however, "FALLING" will make the interrupt trigger only when the pin goes from HIGH to LOW. Read link for more info.

#### Variables

* tickCount - Two variables, one for each motor. When interrupt its triggered, increment the tick count by 1.
* emitterState - One for each emitter. Stores the current state of the emitter

#### Functions

* readReciever() - One method for each reciever. Returns the value read by reciever
* setEmitterState(x) - One method for each emitter. Set the state of the emitter to on or off.
* getSwitchState() - Return the value of the switch
* runMotorTime(m, speed, sec) - Set specific motor at speed for given amount of seconds. Uses delay function to count time.
* runMotorRev(m, speed, rev) - Runs a specific motor at speed for given amount of revolutions. Uses the encoder varible to count revolutions.
* setLED(l, brightness) - Sets a specific led to a certian brightness.
* setBuzzer(strength) - Sets the buzzer to a given strength.

#### More Functions
* turnRight() - Use encoders and tickCounts of both motors to make a percise right turn
* turnLeft() - similar to turnRight()
* goForward() - Use encoders to go straight.
* turnAround() - turnRight * 2

 </details>
 
 <details>
<summary><strong>3D Printed Parts</strong></summary>
 </details>

### Other Resources

<li><a href="https://git-scm.com/book/en/v2" target="_blank"><strong>Git Markdown</strong></a></li>
<li><a href="https://www.sparkfun.com/tutorials/223" target="_blank"><strong>How to Read a Datasheet</strong></a></li>

## KiCad design pcb_files/mouse/mouse_v2.kicad_pcb

Board: 2 copper layers, 84.9 x 94.9 mm, 67 parts (10 on the bottom side), 58 nets.

Parts:
BT1: Battery_Cell; PinSocket_1x02_P2.54mm_Vertical
BZ1: Buzzer; 9x5.5mm Buzzer
C1, C3: 100uF; CP_Radial_D5.0mm_P2.50mm
C2: 0.1uF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C4: 1uF; C_1210_3225Metric_Pad1.42x2.65mm_HandSolder
C9: 10uF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C10: 10uF(Tantalum); C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D0, D1, D2, D3: SFH4545; LED_D3.0mm_Horizontal_O3.81mm_Z2.0mm
D4, D5, D6: LED; LED_0201_0603Metric_Pad0.64x0.40mm_HandSolder
J1: Conn_01x06_Female; PinHeader_1x06_P2.54mm_Vertical
J2: Conn_01x02_Female; PinHeader_1x02_P2.54mm_Vertical
J3: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
J4: I2C_Conn; PinSocket_1x02_P2.54mm_Vertical
M1, M2: Motor_DC; Motor_mouse
MH1, MH2: M3; MountingHole_2.2mm_M2
Q0, Q1, Q2, Q3: Q_Photo_NPN; LED_D3.0mm_Horizontal_O3.81mm_Z2.0mm
R1, R2, R3, R4: 1.8k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5, R6, R7, R8: 35; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R9, R10, R11, R12: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R13, R14, R15, R16, R17: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R18, R22, R23: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R19, R20, R21: R; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
S1: EG1218; SWITCH_SLIDE_500SSP1S2M2QEA
S2, S3: GPTS203211B; SW_PUSH_6mm
SK1, SK2, SK3, SK4: M3; MountingHole_2.2mm_M2
T0, T1, T2, T3, T4: Q_NMOS_DGS; TN0104(TO-92)v2
U1: Teensy4.0; Teensy40
U2: SN754410NE (Half-Bridge); DIP254P762X508-16
U3: LM1085-5.0; TO-263-3_TabPin2
U4, U5: Encoder_3081; PinSocket_1x06_P2.00mm_Vertical

Connections:
/3.3v: Q0.1, Q1.1, Q2.1, Q3.1, U1.16
/5v: BZ1.1, C2.1, D0.2, D1.2, D2.2, D3.2, J1.5, S1.2, U1.33, U2.16, U4.4, U5.4
/Buzzer: R17.2, T4.2, U1.4
/Emitter_0: R9.2, U1.29
/Emitter_1: R10.2, U1.28
/Emitter_2: R11.2, U1.22
/Emitter_3: R12.2, U1.25
/GND: BT1.2, C1.2, C2.2, C3.2, C4.2, C9.2, C10.2, D4.1, D5.1, D6.1, J1.4, J3.2, J4.1, R1.1, R2.1, R3.1, R4.1, R13.1, R14.1, R15.1, R16.1, R23.2, S2.1, S3.1, T0.3, T1.3, T2.3, T3.3, U1.1, U1.17, U2.4, U2.5, U2.12, U2.13, U3.1, U4.1, U5.1
/HC05_KEY: J1.6, J3.1
/HC05_RX: J1.2, U1.40
/HC05_TX: J1.3, U1.39
/LED_1: R19.2, U1.7
/LED_2: R20.2, U1.5
/LED_3: R21.2, U1.6
/M1_backward: U1.10, U2.7
/M1_encoder_A: U1.24, U5.3
/M1_encoder_B: U1.23, U5.2
/M1_forward: U1.13, U2.2
/M1_speed: U1.14, U2.1
/M2_backward: U1.11, U2.15
/M2_encoder_A: U1.3, U4.3
/M2_encoder_B: U1.2, U4.2
/M2_forward: U1.9, U2.10
/M2_speed: U1.8, U2.9
/OUT1: U2.3, U5.5
/OUT2: U2.6, U5.6
/OUT3: U2.11, U4.5
/OUT4: U2.14, U4.6
/PUSH_SW: S2.2, U1.20
/PUSH_SW2: S3.2, U1.12
/Reciever_0: Q0.2, R1.2, U1.30
/Reciever_1: Q1.2, R2.2, U1.27
/Reciever_2: Q2.2, R3.2, U1.21
/Reciever_3: Q3.2, R4.2, U1.26
/SCL2: J2.2, U1.35
/SDA2: J2.1, U1.36
/VUSB: S1.3, U1.34
/V_METER: R22.2, R23.1, U1.41
/vBatt: BT1.1, C1.1, C3.1, C4.1, C9.1, J4.2, R22.1, U2.8, U3.3
unnamed: BZ1.2, R18.1
unnamed: C10.1, S1.1, U3.2
unnamed: D0.1, R5.1
unnamed: D1.1, R6.1
unnamed: D2.1, R7.1
unnamed: D3.1, R8.1
unnamed: D4.2, R19.1
unnamed: D5.2, R20.1
unnamed: D6.2, R21.1
unnamed: R5.2, T0.1
unnamed: R6.2, T1.1
unnamed: R7.2, T2.1
unnamed: R8.2, T3.1
unnamed: R10.1, R14.2, T1.2
unnamed: R11.1, R15.2, T2.2
unnamed: R12.1, R16.2, T3.2
unnamed: R9.1, R13.2, T0.2
unnamed: R17.1, T4.3
unnamed: R18.2, T4.1

## KiCad design Daughter Board/V1 Daughter Board/V1 Daughter Board.kicad_pcb

Parts:
U1, U2: teensy_Teensy4.0; Teensy40_nosmd
U3: HC-05_Breakout

Connections:
/3.3v: U1.16 (3V3), U2.16 (3V3)
/4: U1.4 (2_OUT2), U2.4 (2_OUT2)
/5v: U1.33 (VIN), U2.33 (VIN), U3.2 (VCC)
/7: U1.7 (5_IN2), U2.7 (5_IN2)
/8: U1.8 (6_OUT1D), U2.8 (6_OUT1D)
/9: U1.9 (7_RX2_OUT1A), U2.9 (7_RX2_OUT1A)
/10: U1.10 (8_TX2_IN1), U2.10 (8_TX2_IN1)
/11: U1.11 (9_OUT1C), U2.11 (9_OUT1C)
/12: U1.12 (10_CS_MQSR), U2.12 (10_CS_MQSR)
/13: U1.13 (11_MOSI_CTX1), U2.13 (11_MOSI_CTX1)
/14: U1.14 (12_MISO_MQSL), U2.14 (12_MISO_MQSL)
/15: U1.15 (VBAT), U2.15 (VBAT)
/18: U1.18 (PROGRAM), U2.18 (PROGRAM)
/19: U1.19 (ON_OFF), U2.19 (ON_OFF)
/20: U1.20 (13_SCK_CRX1_LED), U2.20 (13_SCK_CRX1_LED)
/21: U1.21 (14_A0_TX3_SPDIF_OUT), U2.21 (14_A0_TX3_SPDIF_OUT)
/22: U1.22 (15_A1_RX3_SPDIF_IN), U2.22 (15_A1_RX3_SPDIF_IN)
/23: U1.23 (16_A2_RX4_SCL1), U2.23 (16_A2_RX4_SCL1)
/24: U1.24 (17_A3_TX4_SDA1), U2.24 (17_A3_TX4_SDA1)
/25: U1.25 (18_A4_SDA0), U2.25 (18_A4_SDA0)
/26: U1.26 (19_A5_SCL0), U2.26 (19_A5_SCL0)
/27: U1.27 (20_A6_TX5_LRCLK1), U2.27 (20_A6_TX5_LRCLK1)
/28: U1.28 (21_A7_RX5_BCLK1), U2.28 (21_A7_RX5_BCLK1)
/29: U1.29 (22_A8_CTX1), U2.29 (22_A8_CTX1)
/30: U1.30 (23_A9_CRX1_MCLK1), U2.30 (23_A9_CRX1_MCLK1)
/34: U1.34 (VUSB), U2.34 (VUSB)
/BT_RX: U1.2 (0_RX1_CRX2_CS1), U3.5 (RX)
/BT_TX: U1.3 (1_TX1_CTX2_MISO1), U3.4 (TX)
/GND: U1.1 (GND), U1.17 (GND), U2.1 (GND), U2.17 (GND), U3.1 (EN/KEY), U3.3 (GND)
/M2_encoder_A: U1.6 (4_BCLK2), U2.3 (1_TX1_CTX2_MISO1)
/M2_encoder_B: U1.5 (3_LRCLK2), U2.2 (0_RX1_CRX2_CS1)

Board: 2 copper layers, 48.3 x 40.0 mm, 3 parts (1 on the bottom side), 31 nets.

## Code that names these connections

File Test_code/program files/MasterCode.ino:

#define EMIT0 22
#define RECIV0 23
#define EMIT1 21
#define RECIV1 20
#define EMIT3 18
#define RECIV3 19
#define EMIT2 13
#define RECIV2 14
#define EMIT_PULSE_DELAY 10 //ms

#define M1POW 12
#define M1F 11
#define M1B 8
#define M2POW 6
#define M2F 7
#define M2B 9

#define BUZZ 2
#define BUTTON1 15

#define ENCODER_M1_A 17
#define ENCODER_M1_B 16
#define ENCODER_M2_A 1
#define ENCODER_M2_B 0

#define LED_2 3
#define LED_3 4
#define LED_1 5

int countM1 = 0;
int countM2 = 0;

void m1_tick_and_print(){
  countM1++;
  Serial.println(countM1);
}

void m2_tick_and_print(){
  countM2++;
  Serial.println(countM2);
}

void m1_tick(){
  countM1++;
}

void m2_tick(){
  countM2++;
}

void setup() {
  pinMode(BUZZ, OUTPUT);
  pinMode(EMIT0, OUTPUT);
  pinMode(RECIV0, INPUT);
  pinMode(EMIT1, OUTPUT);
  pinMode(RECIV1, INPUT);
  pinMode(RECIV3, INPUT);
  pinMode(EMIT3, OUTPUT);
  pinMode(RECIV2, INPUT);
  pinMode(EMIT2, OUTPUT);
  pinMode(BUTTON1, INPUT);

  pinMode(M1POW, OUTPUT);
  pinMode(M2POW, OUTPUT);
  pinMode(M1F, OUTPUT);
  pinMode(M1B, OUTPUT);
  pinMode(M2F, OUTPUT);
  pinMode(M2B, OUTPUT);

  pinMode(LED_2, OUTPUT);
  pinMode(LED_1, OUTPUT);
  pinMode(LED_3, OUTPUT);

  //setup for encoders, print at each motor tick
  pinMode(ENCODER_M1_A, INPUT);
  attachInterrupt(digitalPinToInterrupt(ENCODER_M1_A), m1_tick_and_print, RISING);
  pinMode(ENCODER_M1_B, INPUT);
  attachInterrupt(digitalPinToInterrupt(ENCODER_M1_B), m1_tick_and_print, RISING);

  pinMode(ENCODER_M2_A, INPUT);
  attachInterrupt(digitalPinToInterrupt(ENCODER_M2_A), m2_tick_and_print, RISING);
  pinMode(ENCODER_M2_B, INPUT);
  attachInterrupt(digitalPinToInterrupt(ENCODER_M2_B), m2_tick_and_print, RISING);
  Serial.begin(9600);
}

void motor1F(int power){
  analogWrite(M1POW, power);
  digitalWrite(M1F, 1);
  digitalWrite(M1B, 0);
}

void motor1B(int power){
  analogWrite(M1POW, power);
  digitalWrite(M1F, 0);
  digitalWrite(M1B, 1);
}

void motor1S(){
  analogWrite(M1POW, 0);
  digitalWrite(M1F, 0);
  digitalWrite(M1B, 0);
}

void motor2F(int power){
  analogWrite(M2POW, power);
  digitalWrite(M2F, 1);
  digitalWrite(M2B, 0);
}

void motor2B(int power){
  analogWrite(M2POW, power);
  digitalWrite(M2F, 0);
  digitalWrite(M2B, 1);
}

void motor2S(){
  analogWrite(M2POW, 0);
  digitalWrite(M2F, 0);
  digitalWrite(M2B, 0);
}

int read_dist(int num){
  int val;
  switch (num)
  {
  case 0:
    digitalWrite(EMIT0, HIGH);
    delay(EMIT_PULSE_DELAY);
    val = analogRead(RECIV0);
    digitalWrite(EMIT0, LOW);
    return val;

  case 1:
    digitalWrite(EMIT1, HIGH);
    delay(EMIT_PULSE_DELAY);
    val = analogRead(RECIV1);
    digitalWrite(EMIT1, LOW);
    return val;

  case 2:
    digitalWrite(EMIT2, HIGH);
    delay(10);
    val = analogRead(RECIV2);
    digitalWrite(EMIT2, LOW);
    return val;

  case 3:
    digitalWrite(EMIT3, HIGH);
    delay(10);
    val = analogRead(RECIV3);
    digitalWrite(EMIT3, LOW);
    return val;
  
  default:
    return 0;
  }

}

void loop() { 

  digitalWrite(LED_2, HIGH);
  digitalWrite(LED_1, HIGH);
  digitalWrite(LED_3, HIGH);
  
  delay(300);
  digitalWrite(LED_2, LOW);
  digitalWrite(LED_1, LOW);
  digitalWrite(LED_3, LOW);

  //test emitters and recievers
  //Serial.print("Emitter0:  "); 
  //Serial.println(read_dist(0));
   
  //Serial.print("Emitter1:  "); 
  //Serial.println(read_dist(1));
  
  //Serial.print("Emitter2:  "); 
  //Serial.println(read_dist(2));
   
  //Serial.print("Emitter3:  "); 
  //Serial.println(read_dist(3));
   
  Serial.print("BUTTON1:  "); 
  Serial.println(digitalRead(BUTTON1));
  //for(int i = 0; i < 10; ++i)
  //{
  //Serial.println();
  //}

  //test motor sequence
  //motor1F(150);
  //motor2F(150);
  //delay(500);
  //motor1B(150);
  //motor2B(150);
  //delay(500);
  //motor1S();
  //motor2S();
  //delay(1000);

  //tone(BUZZ, 100); // Send 1KHz sound signal...
  //delay(1000);        // ...for 1 sec
  //noTone(BUZZ);     // Stop sound...
  delay(1000); 
}

## Commit log

2020-08-21 Board updates
2020-09-02 Updated pins for Teensy, pre traces
2020-09-06 Traces Complete
2020-09-19 Kit-Mouse changes
    Current limiting R's on emitters
    Motors powered by battery
    Big caps on battery
    Debounce circuit on push switch
2020-09-20 Final Schematic and PCB changes
2020-09-21 Updates
    PCB
    Foorprints
2020-09-23 1uF Cap
2020-09-23 Silkscreen changes
2020-09-23 Final fixes
2020-09-23 Final Changes for real this time
2020-09-23 Final Fixes 3
2020-09-25 Pushing Plots
2020-10-10 Testing Images
2020-10-10 Updated Schematic Image
2020-10-10 Update Image
2020-10-10 Motor Image
2020-10-11 Added CAD Files
2020-12-28 Add files via upload
    Updated Dimensions for 27 Rubber Band Wheel
2021-01-20 New Skate Design
    Smaller cross skate design
2021-01-30 Front Skates Added
2021-02-13 started BLE adapter for rev1 of board
2021-03-23 added slot for bluetooth module
2021-03-25 Add files via upload
    Master Code for Micromouse
2021-03-31 started code for stress testing motors
2021-03-31 use unsigned int for motor counts
2021-03-31 add setup delay
2021-03-31 modify PWM frequency
2021-04-10 create arduino version
2021-04-19 tested total current draw(w/o buzzer)
2021-04-20 added nmos driver for buzzer, and voltage meter
2021-04-20 rerouted traces, placed vol meter,
2021-04-20 cleand up some traces
2021-04-21 re-layout power section
2021-04-21 reworked power layout, added second button and key jumper to schem
2021-04-24 reposition emitters
2021-04-25 fixed emiter/reciver traces
2021-04-25 traces update
2021-04-25 added hc05 key jumper
2021-04-25 updated labels
2021-04-26 Daughter Board
    Basic Daughter Board for the HC-05
2021-05-02 changed led to smaller footprint, generated gerbers
2021-05-23 added more test functions
2021-05-30 Draft of build guide
